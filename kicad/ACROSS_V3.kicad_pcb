# Repository okd414-arch/ACROSS_V3_STM32 (continued)

## KiCad design kicad/ACROSS_V3.kicad_pcb (continued)

Parts:
C701, C704: 10uF; chip1608b
C702: 1uF/50V; C_0805_2012Metric
C703: 4.7uF; chip1608b
C705, C707, C708: 100nF; chip1608b
C706: 22uF; chip1608b
D607, D608, D609, D610: 1N4148W; D_SOD-123
J701: GF-8801 小基板 1x10; PinHeader_1x10_P2.54mm_Vertical
J702: 外部OC出力 (ユーロブロック); TerminalBlock_Xinya_XY308-2.54-5P_1x05_P2.54mm_Horizontal
J703: モニタTTL出力 (ユーロブロック); TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
L701: 4.7uH; L_Taiyo-Yuden_NR-40xx
R701, R702, R703, R704, R705, R706, R716, R717: 33; chip1608b
R707, R708, R709, R710: 220; chip1608b
R711: 820 (1206); R_1206_3216Metric
R712: 100k; chip1608b
R713: 33k; chip1608b
R714: 20k; chip1608b
R715: 2.7k; chip1608b
TP701: TP_GPS_10MPPS; TestPoint_Pad_D0.6mm
TP702: TP_GPS_1PPS; TestPoint_Pad_D0.6mm
TP703: TP_5V_D; TestPoint_Pad_D0.6mm
TP704: TP_GND_D; TestPoint_Pad_D0.6mm
U701, U702, U703, U704: EL817S1(B)(TU)-F; SMDIP-4_W7.62mm; LCSC C63268
U705: B2409S-1WR3; Converter_DCDC_SIP4_11.6x6mm_P2.54mm
U706: SY8113BADC; TSOT-23-6
U707: CA-IS3720HS; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C707.1, U707.1 (VDDA); also elsewhere on the board
+5V: C701.1, J701.1; also elsewhere on the board
+5V_D: C706.1, C708.1, L701.2, R714.1, TP703.1 (1_1), U707.8 (VDDB)
+9V_D: C703.1, C704.1, R711.1, R712.1, U705.4 (+VOUT), U706.5 (IN)
+24V: C702.1, U705.2 (+VIN); also elsewhere on the board
/07 GPS小基板接続・絶縁ドメインC (OC出力)・D (モニタTTL)/OC1_OUT: D607.1 (K), J702.1, U701.4
/07 GPS小基板接続・絶縁ドメインC (OC出力)・D (モニタTTL)/OC2_OUT: D608.1 (K), J702.2, U702.4
/07 GPS小基板接続・絶縁ドメインC (OC出力)・D (モニタTTL)/OC3_OUT: D609.1 (K), J702.3, U703.4
/07 GPS小基板接続・絶縁ドメインC (OC出力)・D (モニタTTL)/OC4_OUT: D610.1 (K), J702.4, U704.4
/07 GPS小基板接続・絶縁ドメインC (OC出力)・D (モニタTTL)/OC_COM: D607.2 (A), D608.2 (A), D609.2 (A), D610.2 (A), J702.5, U701.3, U702.3, U703.3, U704.3
GND: C701.2, C702.2, C707.2, J701.2, J701.4, J701.10, U701.2, U702.2, U703.2, U704.2, U705.1 (-VIN), U707.4 (GNDA); also elsewhere on the board
GND_D: C703.2, C704.2, C706.2, C708.2, J703.3, R711.2, R713.2, R715.2, TP704.1 (1_1), U705.3 (-VOUT), U706.2 (GND), U707.5 (GNDB)
GPS_1PPS: R702.1, TP702.1 (1_1); also elsewhere on the board
GPS_10MPPS: R701.1, TP701.1 (1_1); also elsewhere on the board
GPS_ALM_N: R704.1; also elsewhere on the board
GPS_LOCK: R703.1; also elsewhere on the board
GPS_RXD: R706.1; also elsewhere on the board
GPS_TXD: R705.1; also elsewhere on the board
MOTOR_DIR: U707.3 (VI2); also elsewhere on the board
MOTOR_PULSE: U707.2 (VI1); also elsewhere on the board
unnamed: J701.3, R701.2
unnamed: J701.5, R702.2
unnamed: J701.6, R703.2
unnamed: J701.7, R704.2
unnamed: J701.8, R705.2
unnamed: J701.9, R706.2
unnamed: J703.1, R716.2
unnamed: J703.2, R717.2
unnamed: R707.2, U701.1
unnamed: R708.2, U702.1
unnamed: R709.2, U703.1
unnamed: R710.2, U704.1
unnamed: C705.1, U706.1 (BS)
unnamed: R712.2, R713.1, U706.4 (EN)
unnamed: R714.2, R715.1, U706.3 (FB)
unnamed: C705.2, L701.1, U706.6 (LX)
unnamed: R716.1, U707.7 (VO1)
unnamed: R717.1, U707.6 (VO2)
OC1: R707.1; also elsewhere on the board
OC2: R708.1; also elsewhere on the board
OC3: R709.1; also elsewhere on the board
OC4: R710.1; also elsewhere on the board

Notes on the sheet:
GF-8801 小基板 (ブレークアウト) との接続 5V供給、IOは3.3V
ドメインC: 外部OC出力 ×4 (EL817、外部24V・約10mA、エミッタ共通 COM_C)。LED電流 約9.5mA ドメインD: モニタTTL 5V (パルス・方向)。+24V → B2409S (9V) → SY8113 (+5V_D)。9Vに820Ωのダミー負荷 (最小負荷10%) 要確認: 絶縁DC-DC・端子のフットプリント、OC出力のTVS (B7)

Parts:
C301, C302, C303, C304, C305, C306, C307, C308, C309, C310, C311, C312, C315, C316, C317, C320, C321, C322, C323, C324, C325, C326: 100nF; chip1608b
C313, C314: 22uF; chip1608b
C318, C319: 10uF; chip1608b
R301, R302, R303, R304, R305, R306, R307, R308, R309, R310, R311, R312, R313, R314, R315, R316, R317, R318, R319, R320, R321, R322, R323, R324, R331: 56; chip1608b
R325: 100; chip1608b
R326, R327: 10k; chip1608b
R328, R329: 240; chip1608b
U1: STM32MP157AAA3; ST_LFBGA-448_18x18mm_Layout22x22_P0.8mm; LCSC C961771
U301: MT41K512M16VRP-107 IT:P; FBGA-96_8x14mm_Layout9x16_P0.8mm; LCSC C2831669

Connections:
/03 DDR/DDR_ZQ: R328.1, U1.K22 (DDR_ZQ)
DDR_A0: R301.1, U1.K19 (DDR_A0), U301.N3 (A0)
DDR_A1: R302.1, U1.M18 (DDR_A1), U301.P7 (A1)
DDR_A2: R303.1, U1.J18 (DDR_A2), U301.P3 (A2)
DDR_A3: R304.1, U1.J19 (DDR_A3), U301.N2 (A3)
DDR_A4: R305.1, U1.T18 (DDR_A4), U301.P8 (A4)
DDR_A5: R306.1, U1.H19 (DDR_A5), U301.P2 (A5)
DDR_A6: R307.1, U1.U19 (DDR_A6), U301.R8 (A6)
DDR_A7: R308.1, U1.F18 (DDR_A7), U301.R2 (A7)
DDR_A8: R309.1, U1.U18 (DDR_A8), U301.T8 (A8)
DDR_A9: R310.1, U1.H18 (DDR_A9), U301.R3 (A9)
DDR_A10: R311.1, U1.N18 (DDR_A10), U301.L7 (A10/AP)
DDR_A11: R312.1, U1.P19 (DDR_A11), U301.R7 (A11)
DDR_A12: R313.1, U1.N19 (DDR_A12), U301.N7 (A12/~BC)
DDR_A13: R314.1, U1.G18 (DDR_A13), U301.T3 (A13)
DDR_A14: R315.1, U1.P18 (DDR_A14), U301.T7 (A14)
DDR_A15: R331.1, U1.M19 (DDR_A15), U301.M7 (A15)
DDR_BA0: R316.1, U1.K20 (DDR_BA0), U301.M2 (BA0)
DDR_BA1: R317.1, U1.R18 (DDR_BA1), U301.N8 (BA1)
DDR_BA2: R318.1, U1.K18 (DDR_BA2), U301.M3 (BA2)
DDR_CASN: R320.1, U1.M22 (DDR_CASN), U301.K3 (~CAS)
DDR_CKE: R322.1, R326.1, U1.R19 (DDR_CKE), U301.K9 (CKE)
DDR_CLKN: R325.2, U1.N21 (DDR_CLKN), U301.K7 (~CK)
DDR_CLKP: R325.1, U1.N20 (DDR_CLKP), U301.J7 (CK)
DDR_CSN: R321.1, U1.L18 (DDR_CSN), U301.L2 (~CS)
DDR_DQ0: U1.E21 (DDR_DQ0), U301.E3 (DQ0)
DDR_DQ1: U1.F21 (DDR_DQ1), U301.F7 (DQ1)
DDR_DQ2: U1.H21 (DDR_DQ2), U301.F2 (DQ2)
DDR_DQ3: U1.E20 (DDR_DQ3), U301.F8 (DQ3)
DDR_DQ4: U1.J21 (DDR_DQ4), U301.H3 (DQ4)
DDR_DQ5: U1.H20 (DDR_DQ5), U301.H8 (DQ5)
DDR_DQ6: U1.H22 (DDR_DQ6), U301.G2 (DQ6)
DDR_DQ7: U1.G19 (DDR_DQ7), U301.H7 (DQ7)
DDR_DQ8: U1.N22 (DDR_DQ8), U301.D7 (DQ8)
DDR_DQ9: U1.R21 (DDR_DQ9), U301.C3 (DQ9)
DDR_DQ10: U1.P21 (DDR_DQ10), U301.C8 (DQ10)
DDR_DQ11: U1.T20 (DDR_DQ11), U301.C2 (DQ11)
DDR_DQ12: U1.V20 (DDR_DQ12), U301.A7 (DQ12)
DDR_DQ13: U1.R20 (DDR_DQ13), U301.A2 (DQ13)
DDR_DQ14: U1.U21 (DDR_DQ14), U301.B8 (DQ14)
DDR_DQ15: U1.V21 (DDR_DQ15), U301.A3 (DQ15)
DDR_DQM0: U1.G20 (DDR_DQM0), U301.E7 (LDM)
DDR_DQM1: U1.T21 (DDR_DQM1), U301.D3 (UDM)
DDR_DQS0N: U1.G21 (DDR_DQS0N), U301.G3 (~LDQS)
DDR_DQS0P: U1.G22 (DDR_DQS0P), U301.F3 (LDQS)
DDR_DQS1N: U1.R22 (DDR_DQS1N), U301.B7 (~UDQS)
DDR_DQS1P: U1.T22 (DDR_DQS1P), U301.C7 (UDQS)
DDR_ODT: R324.1, U1.L21 (DDR_ODT), U301.K1 (ODT)
DDR_RASN: R319.1, U1.M20 (DDR_RASN), U301.J3 (~RAS)
DDR_RESETN: R327.1, U1.F19 (DDR_RESETN), U301.T2 (~RESET)
DDR_WEN: R323.1, U1.M21 (DDR_WEN), U301.L3 (~WE)
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, R326.2, R327.2, R328.2, R329.2, U301.A9 (V_{SS}), U301.B1 (V_{SSQ}), U301.B3 (V_{SS}), U301.B9 (V_{SSQ}), U301.D1 (V_{SSQ}), U301.D8 (V_{SSQ}), U301.E1 (V_{SS}), U301.E2 (V_{SSQ}), U301.E8 (V_{SSQ}), U301.F9 (V_{SSQ}), U301.G1 (V_{SSQ}), U301.G8 (V_{SS}), U301.G9 (V_{SSQ}), U301.J2 (V_{SS}), U301.J8 (V_{SS}), U301.M1 (V_{SS}), U301.M9 (V_{SS}), U301.P1 (V_{SS}), U301.P9 (V_{SS}), U301.T1 (V_{SS}), U301.T9 (V_{SS}); also elsewhere on the board
unnamed: R329.1, U301.L8 (ZQ)
VDD_DDR: C318.1, C319.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, U301.A1 (V_{DDQ}), U301.A8 (V_{DDQ}), U301.B2 (V_{DD}), U301.C1 (V_{DDQ}), U301.C9 (V_{DDQ}), U301.D2 (V_{DDQ}), U301.D9 (V_{DD}), U301.E9 (V_{DDQ}), U301.F1 (V_{DDQ}), U301.G7 (V_{DD}), U301.H2 (V_{DDQ}), U301.H9 (V_{DDQ}), U301.K2 (V_{DD}), U301.K8 (V_{DD}), U301.N1 (V_{DD}), U301.N9 (V_{DD}), U301.R1 (V_{DD}), U301.R9 (V_{DD}); also elsewhere on the board
VREF_DDR: C315.1, C316.1, C317.1, U1.AB19 (DDR_VREF), U301.H1 (V_{REFDQ}), U301.M8 (V_{REFCA}); also elsewhere on the board
VTT_DDR: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, R301.2, R302.2, R303.2, R304.2, R305.2, R306.2, R307.2, R308.2, R309.2, R310.2, R311.2, R312.2, R313.2, R314.2, R315.2, R316.2, R317.2, R318.2, R319.2, R320.2, R321.2, R322.2, R323.2, R324.2, R331.2; also elsewhere on the board

Notes on the sheet:
DDR3L (SoC側) と終端 (EV1 MB1263 p.8 に倣う)。メモリは1個 (U301) アドレス・コマンド: 56Ω で VTT_DDR へ終端 (8Gb品のためA15も終端、R331)。CLK: 100Ω 差動終端 CKE・RESETN: 10kでプルダウン。VTT_DDR: 56Ω ×25、100nF ×12 + 22uF ×2
DDR3L MT41K512M16VRP-107 IT:P ×1 (8Gb ×16、16bit幅、1GB)。2026-11-27 に2個 (NT5CC256M16 ×2、32bit) から変更 U301 = バイト0/1 (DQ0-15)。SoC のバイト2/3 (DQ16-31、DQS2/3、DQM2/3) は未接続。バイト内のDQの入れ替えは基板設計で行ってよい シンボルは MT41K256M16TW を元に M7 = A15 を追加。フットプリントは ACROSS_V3:FBGA-96_8x14mm (外形 8.0×14.0mm、Micron データシート Rev.D p.9 で確認、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

Parts:
C201, C202, C203: 2.2uF; chip1608b
C204, C237, C238, C239, C240: 100nF; chip1608b
C205, C206, C207, C208, C209, C210, C211, C212, C213, C214, C215, C216, C217, C218, C219, C220, C221, C222, C223, C224, C225, C226, C227, C228, C230, C231, C233, C234, C235, C236: 1uF; chip1608b
C229, C232: 1nF; chip1608b
D201, D202: KT-0603YG (緑); LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2289
D203, D204: KT-0603R (赤); LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286
J201: SWD; PinHeader_1x05_P2.54mm_Vertical
JP201: HSE_SEL; PinHeader_1x03_P2.54mm_Vertical
R201, R202, R203: 10k; chip1608b
R204: 3.0k; chip1608b
R205: 33; chip1608b
R206, R207: 240; chip1608b
R208, R209: 250; chip1608b
SW201: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W8.61mm_P2.54mm_LowProfile
U1: STM32MP157AAA3; ST_LFBGA-448_18x18mm_Layout22x22_P0.8mm; LCSC C961771
Y201: 1XTV10000MDA (10MHz TCXO); Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; LCSC C253701

Connections:
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, D201.1 (K), D202.1 (K), D203.1 (K), D204.1 (K), J201.2, R201.2, R202.2, R203.2, R204.2, U1.A1 (VSS), U1.A19 (VSS), U1.A22 (VSS), U1.AA4 (VSS), U1.AA12 (BYPASS_REG1V8), U1.AA13 (VSS_USBHS), U1.AA16 (VSS_USBHS), U1.AA18 (VSS), U1.AB1 (VSS), U1.AB18 (VSS), U1.AB22 (VSS), U1.B2 (VSS), U1.B19 (VSS), U1.C3 (VSS), U1.C8 (VSS), U1.C11 (VSS), U1.C14 (VSS_DSI), U1.C15 (VSS_DSI), U1.C16 (VSS_DSI), U1.C17 (VSS_DSI), U1.C18 (VSS_DSI), U1.C19 (VSS), U1.C20 (VSS), U1.D4 (VSS), U1.D19 (VSS_PLL2), U1.E5 (VSS), U1.E19 (VSS), U1.F6 (VSS), U1.F7 (VSS), U1.F8 (VSS), U1.F16 (VSS), U1.F20 (VSS), U1.G4 (VSS), U1.G6 (VSS), U1.G8 (VSS), U1.G10 (VSS), U1.G12 (VSS), U1.G14 (VSS), U1.G17 (VSS), U1.H7 (VSS), U1.J9 (VSS), U1.J11 (VSS), U1.J13 (VSS), U1.J17 (VSS), U1.J20 (VSS), U1.K3 (VSS), U1.K7 (VSS), U1.K10 (VSS), U1.K12 (VSS), U1.K14 (VSS), U1.L9 (VSS), U1.L11 (VSS), U1.L13 (VSS), U1.L17 (VSS), U1.L19 (VSS), U1.L20 (VSS), U1.M5 (VSS_PLL), U1.M7 (VSS), U1.M10 (VSS), U1.M12 (VSS), U1.M14 (VSS), U1.N6 (VREF-), U1.N9 (VSS), U1.N11 (VSS), U1.N13 (VSS), U1.N17 (VSS), U1.P3 (VSS), U1.P5 (VSS_ANA), U1.P7 (VSS), U1.P10 (VSS), U1.P12 (VSS), U1.P14 (VSS), U1.P20 (VSS), U1.R6 (VSSA), U1.R8 (VSS), U1.R17 (VSS), U1.T6 (VSSA), U1.T7 (VSS), U1.T9 (VSS), U1.T11 (VSS), U1.T19 (VSS), U1.U6 (VSSA), U1.U7 (VSS), U1.U13 (VSS), U1.U15 (VSS), U1.U17 (VSS), U1.U20 (VSS), U1.V5 (VSS), U1.V16 (VSS), U1.V18 (VSS), U1.V19 (VSS), U1.W17 (VSS), U1.W19 (VSS), U1.Y3 (VSS), U1.Y7 (VSS), U1.Y10 (VSS), U1.Y13 (VSS_USBHS), U1.Y14 (VSS_USBHS), U1.Y15 (VSS_USBHS), U1.Y18 (VSS), U1.Y20 (VSS), Y201.2 (GND); also elsewhere on the board
GPS_10MPPS: JP201.3; also elsewhere on the board
HSE_IN: JP201.2; also elsewhere on the board
LED_G1: R206.1; also elsewhere on the board
LED_G2: R207.1; also elsewhere on the board
LED_R1: R208.1; also elsewhere on the board
LED_R2: R209.1; also elsewhere on the board
NRST: J201.4, U1.R2 (NRST); also elsewhere on the board
unnamed: D201.2 (A), R206.2
unnamed: D202.2 (A), R207.2
unnamed: D203.2 (A), R208.2
unnamed: D204.2 (A), R209.2
unnamed: JP201.1, R205.2
unnamed: C201.1, U1.A18 (VDD1V2_DSI_PHY), U1.B18 (VDD1V2_DSI_REG)
unnamed: C202.1, U1.AB17 (VDDA1V1_REG)
unnamed: C203.1, C204.1, U1.AB12 (VDDA1V8_REG), U1.B14 (VDDA1V8_DSI)
unnamed: R203.1, SW201.6, U1.N3 (BOOT0)
unnamed: R202.1, SW201.5, U1.N4 (BOOT1)
unnamed: R201.1, SW201.4, U1.P4 (BOOT2)
unnamed: C239.1, U1.R1 (NRST_CORE)
unnamed: R204.1, U1.AA17 (USB_RREF)
unnamed: R205.1, Y201.3 (OUT)
OTG_VBUS: U1.V15 (OTG_VBUS); also elsewhere on the board
PWR_ON: U1.V1 (PWR_ON); also elsewhere on the board
SWCLK: J201.1, U1.D17 (JTCK)
SWDIO: J201.3, U1.E17 (JTMS)
USB1_DM: U1.AB15 (USB_DM1); also elsewhere on the board
USB1_DP: U1.AA15 (USB_DP1); also elsewhere on the board
USB2_DM: U1.AA14 (USB_DM2); also elsewhere on the board
USB2_DP: U1.AB14 (USB_DP2); also elsewhere on the board
VDD: C220.1, C221.1, C222.1, C223.1, C224.1, C225.1, C226.1, C227.1, C240.1, J201.5, SW201.1, SW201.2, SW201.3, U1.A14 (VDD_DSI), U1.D18 (VDD_PLL2), U1.M4 (VBAT), U1.M6 (VDD_PLL), U1.M9 (VDD), U1.N5 (VDD_ANA), U1.N8 (VDD), U1.N10 (VDD), U1.P9 (VDD), U1.P11 (VDD), U1.R10 (VDD), U1.R12 (VDD), U1.T13 (VDD), U1.U2 (PDR_ON_CORE), U1.U9 (VDD), U1.U12 (VDD), U1.U14 (VDD), U1.V2 (PDR_ON), Y201.4 (VCC); also elsewhere on the board
VDDA: C236.1, C237.1, U1.P6 (VREF+), U1.R5 (VDDA); also elsewhere on the board
VDD_CORE: C205.1, C206.1, C207.1, C208.1, C209.1, C210.1, C211.1, C212.1, C213.1, C214.1, C215.1, C216.1, C217.1, C218.1, C219.1, U1.H9 (VDDCORE), U1.H11 (VDDCORE), U1.H13 (VDDCORE), U1.H15 (VDDCORE), U1.J8 (VDDCORE), U1.J10 (VDDCORE), U1.J12 (VDDCORE), U1.J14 (VDDCORE), U1.K9 (VDDCORE), U1.K11 (VDDCORE), U1.K13 (VDDCORE), U1.K15 (VDDCORE), U1.L8 (VDDCORE), U1.L10 (VDDCORE), U1.L12 (VDDCORE), U1.L14 (VDDCORE), U1.M11 (VDDCORE), U1.M13 (VDDCORE), U1.M15 (VDDCORE), U1.N12 (VDDCORE), U1.N14 (VDDCORE), U1.P13 (VDDCORE), U1.P15 (VDDCORE), U1.R14 (VDDCORE), U1.T15 (VDDCORE); also elsewhere on the board
VDD_DDR: C228.1, C229.1, C230.1, C231.1, C232.1, C233.1, C234.1, C235.1, U1.E18 (VDDQ_DDR), U1.F17 (VDDQ_DDR), U1.G16 (VDDQ_DDR), U1.H17 (VDDQ_DDR), U1.J16 (VDDQ_DDR), U1.K17 (VDDQ_DDR), U1.L16 (VDDQ_DDR), U1.M17 (VDDQ_DDR), U1.N16 (VDDQ_DDR), U1.P17 (VDDQ_DDR), U1.R16 (VDDQ_DDR), U1.T17 (VDDQ_DDR), U1.U16 (VDDQ_DDR), U1.V17 (VDDQ_DDR), U1.W18 (VDDQ_DDR), U1.Y19 (VDDQ_DDR); also elsewhere on the board
VDD_USB: C238.1, U1.AB13 (VDD3V3_USBHS), U1.AB16 (VDD3V3_USBFS); also elsewhere on the board

Notes on the sheet:
SWD (1×5): 1=SWCLK 2=GND 3=SWDIO 4=NRST 5=VDD
ブートモード BOOT2..0 (ON = 1) 000: UART/USB (書き込み) 010: eMMC (通常) 101: microSD 100: 開発用
状態LED (緑 KT-0603YG ×2、赤 KT-0603R ×2、約5mA)
VDD_CORE
HSEクロック (10MHz、デジタルバイパス): JPで入力源を選ぶ 1-2: 基板上TCXO (既定) 2-3: GPSの10MPPS TCXOのピン配置 (1=NC/VC 2=GND 3=OUT 4=VCC) とフットプリントは未確認
SoC 電源ピン・デカップリング (EV1 MB1263 p.4)、システム系 (p.3)、状態LED、SWD ・同名の電源ピンはシンボル内で束ねてある。デカップリングはEV1と同数で、BGAの直下 (裏面) に置く (0402、ユーザー了承) ・VBAT: RTCバッテリなしでVDDへ (仮)。VDDA/VREF+: PMIC LDO1 ・SWDは専用ピン JTMS-SWDIO (E17) / JTCK-SWCLK (D17)。PDR_ON / PDR_ON_CORE はVDD、BYPASS_REG1V8 はGND
VDDA・VDD_USB
VDD_DDR
VDD

Parts:
C101, C106: 100nF/50V; chip1608b
C102: 22nF; chip1608b
C103: 100uF/35V; CP_Elec_8x10.5
C104, C105: 4.7uF/50V; C_1210_3225Metric
C107, C130: 100nF; chip1608b
C108: 68pF; chip1608b
C109: 6800pF; chip1608b
C110, C111, C112, C113, C115: 22uF; C_1206_3216Metric
C114, C116: 10nF; chip1608b
C117, C131, C132, C133, C134: 22uF; chip1608b
C118, C119, C120, C126, C135, C137, C138: 4.7uF; chip1608b
C121, C122, C123, C124, C125, C127, C136: 10uF; chip1608b
C128, C129, C139: 1uF; chip1608b
D101: SMBJ28A (TVS); D_SMB; LCSC C553979
D102: BZT52C12 (12V); D_SOD-123
D103: SS56C; D_SMC; LCSC C24138
F101: SMD1812P110TF/33 (1.1A); Fuse_1812_4532Metric; LCSC C495358
H101, H102, H103, H104, H105, H106: M3 (非めっき); MountingHole_3.2mm_M3
J101: 24V IN (端子); TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
L101: 10uH PSPMAA0805-100M; L_PSPMAA0805_8.5x8.0mm; LCSC C2962885
L102, L103, L104, L105, L106: 1uH; L_1008_2520Metric
Q101: DMP4065S-7; SOT-23; LCSC C182476
R101: 100k; chip1608b
R102: 150k; chip1608b
R103, R104, R108: 10k; chip1608b
R105: 560k; chip1608b
R106: 39k; chip1608b
R107: 200k; chip1608b
R109: 43k; chip1608b
R110: 8.2k; chip1608b
R111: 33k; chip1608b
R112: 12k; chip1608b
R113: 560; chip1608b
R114, R115: 1.5k; chip1608b
SW101: PONKEY (電源ボタン); SW_SPST_TL3342
TP101: TP_24V; TestPoint_Pad_D0.6mm
TP102: TP_5V; TestPoint_Pad_D0.6mm
TP103, TP112: TP_GND; TestPoint_Pad_D0.6mm
TP104: TP_VDD_CORE; TestPoint_Pad_D0.6mm
TP105: TP_VDD_DDR; TestPoint_Pad_D0.6mm
TP106: TP_VDD; TestPoint_Pad_D0.6mm
TP107: TP_3.3V; TestPoint_Pad_D0.6mm
TP108: TP_VDDA; TestPoint_Pad_D0.6mm
TP109: TP_VDD_USB; TestPoint_Pad_D0.6mm
TP110: TP_VTT_DDR; TestPoint_Pad_D0.6mm
TP111: TP_VDD_SD; TestPoint_Pad_D0.6mm
U101: TPS26635RGET (39Vクランプ); Texas_RGE0024H_VQFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm_Thermal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; LCSC C1850280
U102: TPS54360DDAR; TI_SO-PowerPAD-8_ThermalVias; LCSC C44377
U103: TPS259531DSGR; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; LCSC C2155674
U104: STPMIC1APQR; WFQFN-44-1EP_5x6mm_P0.4mm_EP3.6x4.6mm; LCSC C2156052

Connections:
+3.3V: C128.1, C129.1, C134.1, L106.2, TP107.1 (1_1), U104.19 (LDO25_IN), U104.22 (LDO16_IN), U104.27 (VOUT_4); also elsewhere on the board
+5V: C115.1, C121.1, C122.1, C123.1, C124.1, C125.1, C126.1, L102.1, TP102.1 (1_1), U103.5 (OUT), U104.8 (BUCK1_IN), U104.12 (BUCK2_IN), U104.24 (BUCK4_IN), U104.28 (BUCK3_IN), U104.36 (VIN); also elsewhere on the board
+24V: C103.1, C104.1, C105.1, C106.1, R105.1, TP101.1 (1_1), U101.17 (OUT), U101.18 (OUT), U102.2 (VIN); also elsewhere on the board
/01 電源入力 (24V・降圧5V・保護)・PMIC STPMIC1・取付穴/PM_BST: C117.1, U104.34 (BST_OUT), U104.37 (SW_IN)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, D101.2 (A), D103.2 (A), J101.1, R101.2, R103.2, R104.2, R106.2, R107.1, R110.2, R112.2, R113.2, SW101.1, TP103.1 (1_1), TP112.1 (1_1), U101.7 (PLIM), U101.8 (GND), U101.11 (MODE), U101.15 (PGTH), U101.25 (GND), U102.7 (GND), U102.9 (GNDPAD), U103.8 (GND), U103.9 (GND), U104.6 (GND), U104.10 (GND), U104.15 (GND), U104.26 (GND), U104.30 (GND), U104.32 (GND), U104.41 (GND), U104.45 (GND); also elsewhere on the board
NRST: U104.1 (RST_N); also elsewhere on the board
unnamed: C109.1, R108.2
unnamed: C110.1, C111.1, C112.1, C113.1, L101.2, R109.1, R111.1, U103.3 (IN), U103.4 (IN)
unnamed: D101.1 (K), F101.2, Q101.3 (D)
unnamed: D102.2 (A), Q101.1 (G), R101.1
unnamed: C101.1, D102.1 (K), Q101.2 (S), R102.1, U101.1 (IN), U101.2 (IN), U101.5 (IN_SYS)
unnamed: C107.2, D103.1 (K), L101.1, U102.8 (SW)
unnamed: F101.1, J101.2
unnamed: R104.1, U101.10 (ILIM)
unnamed: R102.2, R103.1, U101.6 (UVLO)
unnamed: C102.1, U101.9 (dVdT)
unnamed: C107.1, U102.1 (BOOT)
unnamed: C108.1, R108.1, U102.6 (COMP)
unnamed: R105.2, R106.1, U102.3 (EN)
unnamed: R109.2, R110.1, U102.5 (FB)
unnamed: R107.2, U102.4 (RT/CLK)
unnamed: R111.2, R112.1, U103.2 (EN/UVLO)
unnamed: R113.1, U103.7 (ILM)
unnamed: C114.1, U103.1 (dVdt)
unnamed: C120.1, U104.40 (INT_LDO)
unnamed: C118.1, U104.18 (LDO2_OUT)
unnamed: C119.1, U104.21 (LDO6_OUT)
unnamed: C116.1, SW101.2, U104.17 (PONKEY_N)
unnamed: L103.1, U104.7 (VLX_1)
unnamed: L104.1, U104.11 (VLX_2)
unnamed: L105.1, U104.29 (VLX_3)
unnamed: L106.1, U104.25 (VLX_4)
unnamed: L102.2, U104.33 (VLX_BST)
PMIC_INT: U104.43 (INT_N); also elsewhere on the board
PMIC_SCL: R115.2, U104.4 (SCL); also elsewhere on the board
PMIC_SDA: R114.2, U104.3 (SDA); also elsewhere on the board
PMIC_WAKEUP: U104.2 (WAKEUP); also elsewhere on the board
PWR_ON: U104.44 (PWRCTRL); also elsewhere on the board
VBUS_SW: U104.38 (SW_OUT); also elsewhere on the board
VDD: C130.1, C133.1, L105.2, R114.1, R115.1, TP106.1 (1_1), U104.31 (VOUT_3), U104.42 (VIO); also elsewhere on the board
VDDA: C135.1, TP108.1 (1_1), U104.23 (LDO1_OUT); also elsewhere on the board
VDD_CORE: C131.1, L103.2, TP104.1 (1_1), U104.5 (VOUT_1); also elsewhere on the board
VDD_DDR: C127.1, C132.1, L104.2, TP105.1 (1_1), U104.9 (VOUT_2), U104.13 (LDO3_IN); also elsewhere on the board
VDD_SD: C138.1, TP111.1 (1_1), U104.20 (LDO5_OUT); also elsewhere on the board
VDD_USB: C137.1, TP109.1 (1_1), U104.39 (LDO4_OUT); also elsewhere on the board
VREF_DDR: C139.1, U104.16 (VREF); also elsewhere on the board
VTT_DDR: C136.1, TP110.1 (1_1), U104.14 (LDO3_OUT); also elsewhere on the board

Notes on the sheet:
5V eFuse の設定 UVLO: 1.2V×(33k+12k)/12k = 4.5V ILIM: 2000/(I−0.04) → 560Ω で約3.61A
PMIC STPMIC1APQR (EV1 MB1263 p.5 を転記)。インダクタは全て 1uH (DFE252012P-1R0M 相当、2520)。レール割当は「PMICレール割当と電源設計方針.md」 BUCK1=VDD_CORE BUCK2=VDD_DDR BUCK3=VDD (SoC IO 3.3V) BUCK4=+3.3V (周辺) LDO1=VDDA LDO3=VTT_DDR、 LDO4=VDD_USB、LDO5=VDD_SD、VREF=VREF_DDR、PWR_SW2=VBUS_SW (USB-1)。LDO2/LDO6/VBUS_OTG は未使用 要確認: STPMIC1の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
端子はユーロブロック (後日選定)
24V eFuse の設定 UVLO: 1.2V×(150k+10k)/10k = 19.2V 起動 ILIM: 18/10k = 1.8A MODE=GND: 自動再試行、SHDN: 開放で有効 (内部2.7V) PLIM・PGTH: GND (未使用)
入力コンデンサ: BUCK1〜4_IN・VLX_BST 10uF ×5、VIN 4.7uF、 LDO3_IN 10uF、LDO16/25_IN 1uF ×2、VIO 100nF
BUCK・LDO・VREF の出力コンデンサ
取付穴 M3 (非めっき) ×6: 四隅 + 長辺の中間
電源入力: DC24V (ACアダプタ 24V/2A)。設計は ACROSS_V3_24V入力電源設計.md 上段: 入力端子 → PTC 1.1A → TVS SMBJ28A → 逆接続保護PMOS → 24V eFuse TPS26635 (39Vクランプ、UVLO 19.2V、1.8A) → +24V 下段: +24V → 降圧 TPS54360 (500kHz) → +5V_BK → 5V eFuse TPS259531 (5.7Vクランプ、UVLO 4.49V、約3.7A) → +5V

Board: 8 copper layers, 382 parts (51 on the bottom side), 310 nets, no tracks yet.
