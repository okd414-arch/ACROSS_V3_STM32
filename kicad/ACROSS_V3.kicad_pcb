# Repository okd414-arch/ACROSS_V3_STM32

File README.md:

# ACROSS V3 (STM32MP157 版、DDR3L 1個構成)

STM32MP157AAA3 (LFBGA448) 1枚の基板 (160×100 mm、8 層、JLCPCB 発注) の設計データです。Zynq で動いていた `across_app` を置き換えます。サーボアンプへ、uint32 のパルス間隔 (50 MHz ティック) をモーターパルス列として正確に再生するのが中核機能です。

**この版は DDR3L を 1個 (MT41K512M16VRP-107 IT:P、8Gbit ×16、1GB) にした版です** (2026-11-27)。NT5CC256M16 ×2 (32bit) の版とは別です。現在の状態は、回路図が 1個構成に更新済み、**基板はまだ 2個構成の配置・配線のまま**です。

## Zynq 版 (FPGA) の機能と STM32MP157 での置き換え

時間の正確さが要る所 (パルス出力・エンコーダ・1PPS の保持) は、**ハードウェアのタイマと DMA** で置き換えます。ソフトの判断が要る所 (時刻管理、パルス表の作成、通信) は、**Linux の across_app** をほぼそのまま使います。FPGA のロジックが担っていた分は、**Cortex-M4 のファームウェア**で補います。

| # | 機能 | Zynq 版 (FPGA) | STM32MP157 版 | 状態 |
|---|---|---|---|---|
| 1 | パルス列の送出 (uint32 間隔、50 MHz 基準、最大 256 MB ×2) | FPGA がメモリのテーブルを DMA で読んでパルスにする | DDR → MDMA → SRAM (ピンポン) → DMA1/2 → **TIM2 (32bit) の ARR を更新する PWM** (CCR は固定) | 方式決定。評価ボードでの検証は未 |
| 2 | パルステーブルの作成 (加速 ACC、FM 変調) | PS 側の across_app が展開 (`SET ACC PULSE`、`SET FM PULSE`) | **A7 の across_app** が起動時に DDR (1GB) へ全展開。走行中は SD/eMMC に触れない | 流用 |
| 3 | 基準クロック | GPS の 10MPPS を FPGA に入力 | **HSE (10 MHz、デジタルバイパス) → PLL3 200 MHz → TIM2 (PSC = 3) = 50 MHz**。基板上の 10 MHz 発振器と GPS の 10MPPS をジャンパーで選ぶ | 方式決定 |
| 4 | 1PPS 同期のカウンタ (エンコーダ値を 1PPS に同期して記録、リセットされない 1PPS カウンタ) | FPGA のレジスタ (READ_REG[19]・[29]) | **TIM5 の入力キャプチャ (PH12、CH3)** で、1PPS の立ち上がり時のエンコーダ値をハードウェアで保持。リセットされない 1PPS カウンタは M4 のソフトで数える | 要設計 |
| 5 | エンコーダの積算 (A/B、分解能 200〜4096、最大 60 Hz) | FPGA のカウンタ | **TIM5 のエンコーダモード (32bit、PH10/PH11)**。Z 相は入力キャプチャ (PI0、CH4) | ピン決定済み |
| 6 | 位相合わせ (`arrangePhase`) | FPGA が、モーターの位相を合わせて、トリガ待ちの状態にする | **M4 のファームウェアで再実装** (エンコーダ値・Z 相を見て、パルス送出の開始位置を調整) | **要確認** (FPGA の仕様が未確認) |
| 7 | FM 変調 (加速のあとの周波数変調) | FPGA のロジック | パルステーブルに展開する (#1・#2 と同じ流れ)。M4 で ARR を変調する案もある | **要確認** |
| 8 | 加速開始のトリガ、時刻管理 (`startTime`、`reverseCycleTime`、CW/CCW を交互に) | PS の across_app が時刻を見て、FPGA へ開始を指示 | **A7 の across_app** が時刻を管理し、**M4 へ開始を通知**する (IPCC / RPMsg、または共有メモリ) | 要設計 |
| 9 | 方向出力 (CW/CCW) | FPGA の出力 (`GPIO_ACTIVATE_ON_CW/CCW`) | M4 の GPIO。RS-422、TTL 5V (モニタ用)、オープンコレクタ (M_DIR_OC) の 3系統を常に出力 | 回路図済み |
| 10 | モーターパルスの出力 | FPGA の出力 | **TIM2_CH1 (PG8)** → 高速デジタルアイソレータ → RS-422 ドライバ。TTL 5V のモニタ出力も別系統 | 回路図済み |
| 11 | FPGA コアのリセット (`GPIO_RESET_ACROSS_CORE`) | AXI GPIO | M4 ファームウェアの再起動 (remoteproc)、または M4 側のソフトのリセット | 要設計 |
| 12 | レジスタの読み書き (`/dev/uio`、`REGISTER?`、`monitor`、`verbose` ログ) | `/dev/uio` で FPGA のレジスタを操作 | **A7 ↔ M4 の共有メモリ (RPMsg)** に置き換える。across_app は、この部分だけ書き換える | 要設計 |
| 13 | GPS の時刻 (NTP、時刻合わせ) | PS の Linux (gpsd/chrony) と推測 | **A7 の Linux** のまま。UART7 (GF-8801) + 1PPS (PG3、pps-gpio) | ピン決定済み。Zynq 版の構成は要確認 |
| 14 | 運転の制御 (UDP 8000、auto_launcher.py、ログ) | PS の Linux | **A7 の Linux** のまま (Ethernet は LAN8720A、RMII) | 流用 |
| 15 | 状態の表示 | MicroZed の LED | 状態 LED を 4個 (緑 ×2、赤 ×2) | 回路図済み |
| 16 | 外部との絶縁、保護 | ドーターカード | 絶縁ドメイン (A: サーボ側、C: 外部 OC、D: モニタ TTL)。GPS は小基板 (GF-8801) をヘッダ (J701) で接続。24 V 入力 | 回路図済み |

「要確認」は、FPGA の RTL (位相合わせ・FM 変調) をまだ確認していないものです。詳しくは `ACROSS_V3_設計メモ.md` の「次の作業」を参照してください。

## まず読むもの
1. `ACROSS_V3_引き継ぎ資料.md` — 現在の状態、決定事項、残作業 (先頭の「★★」の節が最新)
2. `ACROSS_V3_回路図作成メモ.md` — 回路図の規約、設計の決定、フットプリントの割り当て
3. `CLAUDE.md` — 作業の指示 (回答は日本語、など)

## フォルダ
| 場所 | 中身 |
|---|---|
| `ACROSS_V3_*.md`、`*.csv` | 設計メモ、部品選定、ピン割り当て、電源見積もり、配線計画など |
| `kicad/` | KiCad 10 のプロジェクト (`ACROSS_V3.kicad_pro`)。回路図 7 シート (`01_…`〜`07_…`)、基板 `ACROSS_V3.kicad_pcb`、自作ライブラリ `ACROSS_V3.pretty`・`ACROSS_V3.kicad_sym`、設計ルール `ACROSS_V3.kicad_dru` |
| `kicad/tools/` | Python のスクリプト (配置・配線・長さ合わせ・シルクなど) |
| `STM32MP157F-EV1/` | ST の評価ボード (EV1) の回路図と基板データ。DDR などの参考用 |
| `データシート/` | データシートの一覧のみ (PDF は入れていません) |

## 開くとき
- **KiCad 10** で `kicad/ACROSS_V3.kicad_pro` を開きます。
- 個人ライブラリ (`0my_*` の小さい記号、`01_MY` のフットプリント) は作者の PC の `C:\OneDrive_link\KiCAD\` にあります。持っていない場合は、記号や足跡が見つからない警告が出ます (一部は `kicad/ACROSS_V3.kicad_sym`・`ACROSS_V3.pretty` に入っています)。
- `kicad/tools` の Python スクリプトには、作者の PC の絶対パス (`C:\MyWorks\ACROSS_V3_STM32` など) が書いてあります。別の場所で動かすときは書き換えてください。
- 回路図は GUI で編集済みです。スクリプトで作り直さないでください。

## 注意
- 設計のデータは作業中です。発注に使う前に、`ACROSS_V3_引き継ぎ資料.md` の「残作業」を確認してください。

## KiCad design kicad/ACROSS_V3.kicad_pcb

Notes on the sheet:
ACROSS V3 (STM32MP157AAA3) 回路図 24V入力 / STPMIC1 / DDR3L×2 / eMMC / LAN8720A / RGBパネル / 絶縁ドメインA〜D

Parts:
C501, C502: 22pF; chip1608b
C503, C504, C505, C509, C511, C512: 100nF; chip1608b
C506, C510: 10uF; chip1608b
C507: 1uF; chip1608b
C508: 470pF; chip1608b
FB501: 600R@100MHz; chip1608
J501: HR911105A; RJ45_Hanrun_HR911105A_Horizontal; LCSC C12074
J502: XDFC-0522-45P (LCD FPC); FPC_XDFC-0522-45P_0.5mm_BackFlip; LCSC C22363834
J503: J_BLTEST; PinHeader_1x02_P2.54mm_Vertical
Q501: 2N7002; SOT-23
R501, R502, R503, R505, R506, R507, R516: 10k; chip1608b
R504: 1.5k; chip1608b
R508: 33; chip1608b
R509: 12.1k; chip1608b
R510, R511, R512, R513: 51; chip1608b
R514, R515: 2.2k; chip1608b
R517: 47 (1206); R_1206_3216Metric
R518: 100; chip1608b
R519: 100k; chip1608b
TP501: TP_BL_EN; TestPoint_Pad_D0.6mm
U501: LAN8720AI-CP-TR; VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_ThermalVias; LCSC C17146
U502: AL5809-60P1-7; D_PowerDI-123; LCSC C154921
Y501: 25MHz X322525MOB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9006

Connections:
+3.3V: C503.1, C504.1, C505.1, C506.1, C510.1, C511.1, C512.1, FB501.1, J502.5, J502.41, J502.42, R501.1, R502.1, R503.1, R504.1, R510.1, R511.1, R512.1, R513.1, R514.1, R515.1, R516.1, U501.1 (VDD2A), U501.9 (VDDIO), U501.19 (VDD1A); also elsewhere on the board
+24V: R517.1; also elsewhere on the board
/05 Ethernet LAN8720A・LCD・タッチ・バックライト/PHY_LED1: R507.1, U501.3 (LED1/REGOFF)
/05 Ethernet LAN8720A・LCD・タッチ・バックライト/PHY_LED2: R506.1, U501.2 (LED2/~INTSEL)
/05 Ethernet LAN8720A・LCD・タッチ・バックライト/PHY_RXER: R505.1, U501.10 (RXER/PHYAD0)
BL_EN: TP501.1 (1_1); also elsewhere on the board
BL_PWM: R518.1; also elsewhere on the board
DISP: J502.32; also elsewhere on the board
ETH_CRS_DV: R503.2, U501.11 (CRS_DV/MODE2); also elsewhere on the board
ETH_MDC: U501.13 (MDC); also elsewhere on the board
ETH_MDIO: R504.2, U501.12 (MDIO); also elsewhere on the board
ETH_REF_CLK: R508.2; also elsewhere on the board
ETH_RXD0: R501.2, U501.8 (RXD0/MODE0); also elsewhere on the board
ETH_RXD1: R502.2, U501.7 (RXD1/MODE1); also elsewhere on the board
ETH_TXD0: U501.17 (TXD0); also elsewhere on the board
ETH_TXD1: U501.18 (TXD1); also elsewhere on the board
ETH_TX_EN: U501.16 (TXEN); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, J501.8, J501.SH, J502.30, J502.36, Q501.2 (S), R505.2, R506.2, R507.2, R509.2, R519.2, U501.25 (VSS), Y501.2 (G), Y501.4 (G); also elsewhere on the board
LCD_B0: J502.22; also elsewhere on the board
LCD_B1: J502.23; also elsewhere on the board
LCD_B2: J502.24; also elsewhere on the board
LCD_B3: J502.25; also elsewhere on the board
LCD_B4: J502.26; also elsewhere on the board
LCD_B5: J502.27; also elsewhere on the board
LCD_B6: J502.28; also elsewhere on the board
LCD_B7: J502.29; also elsewhere on the board
LCD_CLK: J502.31; also elsewhere on the board
LCD_DE: J502.35; also elsewhere on the board
LCD_G0: J502.14; also elsewhere on the board
LCD_G1: J502.15; also elsewhere on the board
LCD_G2: J502.16; also elsewhere on the board
LCD_G3: J502.17; also elsewhere on the board
LCD_G4: J502.18; also elsewhere on the board
LCD_G5: J502.19; also elsewhere on the board
LCD_G6: J502.20; also elsewhere on the board
LCD_G7: J502.21; also elsewhere on the board
LCD_HSYNC: J502.33; also elsewhere on the board
LCD_R0: J502.6; also elsewhere on the board
LCD_R1: J502.7; also elsewhere on the board
LCD_R2: J502.8; also elsewhere on the board
LCD_R3: J502.9; also elsewhere on the board
LCD_R4: J502.10; also elsewhere on the board
LCD_R5: J502.11; also elsewhere on the board
LCD_R6: J502.12; also elsewhere on the board
LCD_R7: J502.13; also elsewhere on the board
LCD_VSYNC: J502.34; also elsewhere on the board
unnamed: C509.1, FB501.2, J501.4 (TCT), J501.5 (RCT)
unnamed: J501.3 (RD+), R512.2, U501.23 (RXP)
unnamed: J501.6 (RD-), R513.2, U501.22 (RXN)
unnamed: J501.1 (TD+), R510.2, U501.21 (TXP)
unnamed: J501.2 (TD-), R511.2, U501.20 (TXN)
unnamed: J502.1, J503.1, R517.2
unnamed: J502.2, J502.3, J502.4, J503.2, U502.1 (In)
unnamed: Q501.3 (D), U502.2 (Out)
unnamed: Q501.1 (G), R518.2, R519.1
unnamed: R509.1, U501.24 (RBIAS)
unnamed: C507.1, C508.1, U501.6 (VDDCR)
unnamed: C501.1, U501.5 (XTAL1/CLKIN), Y501.1
unnamed: C502.1, U501.4 (XTAL2), Y501.3
unnamed: R508.1, U501.14 (~INT/REFCLKO)
PHY_RST: U501.15 (~RST); also elsewhere on the board
TP_INT: J502.38, R516.2; also elsewhere on the board
TP_RST: J502.37; also elsewhere on the board
TP_SCL: J502.40, R515.2; also elsewhere on the board
TP_SDA: J502.39, R514.2; also elsewhere on the board

Notes on the sheet:
Ethernet 100Mbps: LAN8720A (RMII) + RJ45 HR911105A (トランス内蔵) REF_CLK: PHYが25MHz水晶から50MHzを作り nINT/REFCLKO から出力 (LED2/nINTSEL を10kでプルダウン) ストラップ: MODE[2:0]=111 (自動ネゴ、10kプルアップ)、PHYAD0=0 (10kプルダウン)、REGOFF=0 (内部1.2V) 要確認: 25MHz水晶の負荷容量 (X322525MOB4SI) と負荷コンデンサ値、RJ45のLEDは未接続
バックライト
パネル DT050CTFT-IPS-SHB-PTS (800×480、24bit RGB、タッチ ST1633I)。FPC 45P 0.5mm (XDFC-0522-45P) バックライト: LED 6直×3並 (VF約18.3V、60mA)。アノード=+24V (直列47Ω)、カソード ×3 → AL5809-60 (60mA定電流) → NMOS (BL_PWM、200Hz以下) J_BLTEST: アノード/カソード (AL5809の前) のテスト用2ピン。BL_EN (PE11) は未使用 (テストポイントのみ) 要確認: FPCコネクタのフットプリント (未作成)、AL5809の損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

Parts:
C601: 1uF/50V; C_0805_2012Metric
C602: 4.7uF; chip1608b
C603, C606: 10uF; chip1608b
C604, C607, C609, C610, C611, C612, C613, C614: 100nF; chip1608b
C605, C608: 22uF; chip1608b
D601, D602, D603, D605, D606: SM712; SOT-23; LCSC C404012
D604: 1N4148W; D_SOD-123
J601: エンコーダ入力 (ユーロブロック); TerminalBlock_Xinya_XY308-2.54-9P_1x09_P2.54mm_Horizontal
J602: サーボ出力 (ユーロブロック); TerminalBlock_Xinya_XY308-2.54-7P_1x07_P2.54mm_Horizontal
L601, L602: 4.7uH; L_Taiyo-Yuden_NR-40xx
R601, R605: 100k; chip1608b
R602, R606: 33k; chip1608b
R603: 20k; chip1608b
R604: 2.7k; chip1608b
R607, R613: 10k; chip1608b
R608: 2.2k; chip1608b
R609, R610, R611: 120; chip1608b
R612: 2.2k (1206); R_1206_3216Metric
R614: 220; chip1608b
SW601: Z相 RS-422/OC 切替; SW_SPDT_SMD_6.7x2.8mm
SW602: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W8.61mm_P2.54mm_LowProfile
TP601: TP_5V_A; TestPoint_Pad_D0.6mm
TP602: TP_3V3_A; TestPoint_Pad_D0.6mm
TP603: TP_GND_A; TestPoint_Pad_D0.6mm
U601: B2409S-1WR3; Converter_DCDC_SIP4_11.6x6mm_P2.54mm
U602, U603: SY8113BADC; TSOT-23-6
U604: AM26LV32EIDR; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C527448
U605, U609: EL817S1(B)(TU)-F; SMDIP-4_W7.62mm; LCSC C63268
U606: CA-IS3741HW; SOIC-16W_7.5x10.3mm_P1.27mm; LCSC C428890
U607: CA-IS3720HS; SOIC-8_3.9x4.9mm_P1.27mm
U608: AM26C31IDR; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C34923

Connections:
+3.3V: C611.1, C612.1, U606.10 (ENB), U606.16 (VDDB), U607.1 (VDDA); also elsewhere on the board
+3.3V_A: C608.1, C609.1, C610.1, L602.2, R607.1, R613.1, TP602.1 (1_1), U604.4 (G), U604.16 (VDD), U606.1 (VDDA), U606.7 (ENA)
+5V_A: C605.1, C613.1, C614.1, L601.2, R603.1, TP601.1 (1_1), U607.8 (VDDB), U608.4 (G), U608.16 (VCC)
+9V_A: C602.1, C603.1, C606.1, R601.1, R605.1, U601.4 (+VOUT), U602.5 (IN), U603.5 (IN)
+24V: C601.1, U601.2 (+VIN); also elsewhere on the board
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/DIR_A: U607.6 (VO2), U608.7 (2A)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_A+: D601.1 (A1), J601.1, SW602.1, U604.2 (1A)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_A-: D601.2 (A2), J601.2, R609.2, U604.1 (1B)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_A_RX: U604.3 (1Y), U606.3 (VI1)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_B+: D602.1 (A1), J601.3, SW602.2, U604.6 (2A)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_B-: D602.2 (A2), J601.4, R610.2, U604.7 (2B)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_B_RX: U604.5 (2Y), U606.4 (VI2)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_Z+: D603.1 (A1), J601.5, SW602.3, U604.10 (3A)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_Z-: D603.2 (A2), J601.6, R611.2, U604.9 (3B)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_Z_OC: R613.2, SW601.3 (C), U605.4
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/ENC_Z_RX: SW601.1 (A), U604.11 (3Y)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/M_DIRN: D606.2 (A2), J602.4, U608.5 (2Z)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/M_DIRP: D606.1 (A1), J602.3, U608.6 (2Y)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/M_PULSEN: D605.2 (A2), J602.2, U608.3 (1Z)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/M_PULSEP: D605.1 (A1), J602.1, U608.2 (1Y)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/PULSE_A: U607.7 (VO1), U608.1 (1A)
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/Z_24V: J601.7, R612.2
/06 絶縁ドメインA サーボ (エンコーダ・パルス)/Z_OC: D604.2 (A), J601.8, U605.2
ENC_A: U606.14 (VO1); also elsewhere on the board
ENC_B: U606.13 (VO2); also elsewhere on the board
ENC_Z: U606.12 (VO3); also elsewhere on the board
GND: C601.2, C611.2, C612.2, U601.1 (-VIN), U606.9 (GNDB), U606.11 (VI4), U606.15 (GNDB), U607.4 (GNDA), U609.2; also elsewhere on the board
GND_A: C602.2, C603.2, C605.2, C606.2, C608.2, C609.2, C610.2, C613.2, C614.2, D601.3 (common), D602.3 (common), D603.3 (common), D605.3 (common), D606.3 (common), J601.9, J602.5, R602.2, R604.2, R606.2, R608.2, TP603.1 (1_1), U601.3 (-VOUT), U602.2 (GND), U603.2 (GND), U604.8 (GND), U604.12 (~G), U605.3, U606.2 (GNDA), U606.8 (GNDA), U607.5 (GNDB), U608.8 (GND), U608.9 (3A), U608.12 (nG), U608.15 (4A)
MOTOR_DIR: U607.3 (VI2); also elsewhere on the board
MOTOR_PULSE: U607.2 (VI1); also elsewhere on the board
M_DIR_OC: R614.1; also elsewhere on the board
unnamed: D604.1 (K), R612.1, U605.1
unnamed: J602.6, U609.4
unnamed: J602.7, U609.3
unnamed: R609.1, SW602.6
unnamed: R610.1, SW602.5
unnamed: R611.1, SW602.4
unnamed: R614.2, U609.1
unnamed: SW601.2 (B), U606.5 (VI3)
unnamed: C604.1, U602.1 (BS)
unnamed: R601.2, R602.1, U602.4 (EN)
unnamed: R603.2, R604.1, U602.3 (FB)
unnamed: C604.2, L601.1, U602.6 (LX)
unnamed: C607.1, U603.1 (BS)
unnamed: R605.2, R606.1, U603.4 (EN)
unnamed: R607.2, R608.1, U603.3 (FB)
unnamed: C607.2, L602.1, U603.6 (LX)

Notes on the sheet:
絶縁ドメインA (サーボアンプ側)。電源: +24V → B2409S (9V) → SY8113 ×2 (+5V_A、+3.3V_A) エンコーダ A/B/Z: RS-422 → AM26LV32 (120Ω終端) → CA-IS3741 → SoC。Z相はスライドスイッチで RS-422 / OC (24V、EL817) を選ぶ (OC側は論理反転) パルス・方向: SoC → CA-IS3720 → AM26C31 (5V駆動、終端なし)。M_DIR_OC: EL817 (OC出力)。外部線にSM712 要確認: 絶縁DC-DC・スライドスイッチ・端子のフットプリント、OC/24V入力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

Parts:
C401, C403, C405, C407, C410, C414, C415: 100nF; chip1608b
C402, C404, C406: 2.2uF; chip1608b
C408, C409: 10uF; chip1608b
C411: 4.7uF; chip1608b
C412, C413: 1uF; chip1608b
F401: SMD1206B020TF/24 (200mA); Fuse_1206_3216Metric; LCSC C269111
J401: TF-01A (microSD); microSD_TF-01A_Hroparts; LCSC C91145
J402: USB-A (Host) USB-A-S-F-B-TH; USB_A_Samtec_USB-A-S-X-X-TH_Horizontal; LCSC C3197723
J403: TYPE-C-31-M-12 (USB-2 OTG); USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J404: TYPE-C-31-M-12 (Debug); USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
R401, R402, R403, R409, R414: 10k; chip1608b
R404, R405, R406, R407, R408: 47k; chip1608b
R410: 22; chip1608b
R411, R412, R415, R416: 5.1k; chip1608b
R413: 0; chip1608b
U1: STM32MP157AAA3; ST_LFBGA-448_18x18mm_Layout22x22_P0.8mm; LCSC C961771
U401: KLM8G1GETF-B041; LFBGA-153_11.5x13mm_Layout14x14_P0.5mm; LCSC C499918
U402, U403, U404: USBLC6-2SC6; SOT-23-6; LCSC C7519
U405: CH340N; JEITA_SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2977777
U406: TC74LCX541F; SO-20_5.3x12.6mm_P1.27mm

Connections:
+3.3V: C403.1, C404.1, C414.1, C415.1, U401.E6 (VCC), U401.F5 (VCC), U401.J10 (VCC), U401.K9 (VCC), U405.5 (VCC), U405.8 (V3), U406.20 (VCC); also elsewhere on the board
/04 SoC GPIO (ピン割当)・eMMC・microSD・USB・デバッグUART/PF0: U1.E10 (PF0), U406.2 (A0)
/04 SoC GPIO (ピン割当)・eMMC・microSD・USB・デバッグUART/PF1: U1.B9 (PF1), U406.3 (A1)
/04 SoC GPIO (ピン割当)・eMMC・microSD・USB・デバッグUART/PF2: U1.F13 (PF2), U406.4 (A2)
/04 SoC GPIO (ピン割当)・eMMC・microSD・USB・デバッグUART/PF3: U1.V3 (PF3), U406.5 (A3)
/04 SoC GPIO (ピン割当)・eMMC・microSD・USB・デバッグUART/PF4: U1.F9 (PF4), U406.6 (A4)
BL_EN: U1.D5 (PE11); also elsewhere on the board
BL_PWM: U1.AA5 (PB1); also elsewhere on the board
DBG_RX: U1.V13 (PB2), U405.6 (TXD)
DBG_TX: U1.U11 (PG11), U405.7 (RXD)
DISP: U1.W14 (PE10); also elsewhere on the board
EMMC_CK: U1.A10 (PE3), U401.M6 (CLK)
EMMC_CMD: R402.2, U1.D11 (PG6), U401.M5 (CMD)
EMMC_D0: R401.2, U1.A13 (PB14), U401.A3 (DAT0)
EMMC_D1: U1.B12 (PB15), U401.A4 (DAT1)
EMMC_D2: U1.A12 (PB3), U401.A5 (DAT2)
EMMC_D3: U1.C13 (PB4), U401.B2 (DAT3)
EMMC_D4: U1.B13 (PA8), U401.B3 (DAT4)
EMMC_D5: U1.A11 (PA9), U401.B4 (DAT5)
EMMC_D6: U1.C12 (PE5), U401.B5 (DAT6)
EMMC_D7: U1.B11 (PD3), U401.B6 (DAT7)
EMMC_RST: R403.2, U1.Y2 (PE2), U401.K5 (RSTn)
ENC_A: U1.B1 (PH10); also elsewhere on the board
ENC_B: U1.B3 (PH11); also elsewhere on the board
ENC_Z: U1.D1 (PI0); also elsewhere on the board
ETH_CRS_DV: U1.Y9 (PA7); also elsewhere on the board
ETH_MDC: U1.AB3 (PC1); also elsewhere on the board
ETH_MDIO: U1.AB2 (PA2); also elsewhere on the board
ETH_REF_CLK: U1.V4 (PA1); also elsewhere on the board
ETH_RXD0: U1.AB6 (PC4); also elsewhere on the board
ETH_RXD1: U1.AA6 (PC5); also elsewhere on the board
ETH_TXD0: U1.AA1 (PG13); also elsewhere on the board
ETH_TXD1: U1.AA2 (PG14); also elsewhere on the board
ETH_TX_EN: U1.Y5 (PB11); also elsewhere on the board
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, J401.6 (VSS), J401.SH (SHIELD), J402.4 (GND), J402.SH (Shield), J403.A1 (GND), J403.A12 (GND), J403.B1 (GND), J403.B12 (GND), J403.SH (SHIELD), J404.A1 (GND), J404.A12 (GND), J404.B1 (GND), J404.B12 (GND), J404.SH (SHIELD), R411.2, R412.2, R415.2, R416.2, U401.A6 (VSS), U401.C4 (VSS), U401.E7 (VSS), U401.G5 (VSS), U401.H10 (VSS), U401.J5 (VSS), U401.K8 (VSS), U401.N2 (VSS), U401.N5 (VSS), U401.P4 (VSS), U401.P6 (VSS), U402.2 (GND), U403.2 (GND), U404.2 (GND), U405.3 (GND), U406.1 (G1), U406.7 (A5), U406.8 (A6), U406.9 (A7), U406.10 (GND), U406.19 (G2); also elsewhere on the board
GPS_1PPS: U1.F5 (PH12), U1.U4 (PG3); also elsewhere on the board
GPS_ALM_N: U1.Y4 (PG1); also elsewhere on the board
GPS_LOCK: U1.W5 (PG0); also elsewhere on the board
GPS_RXD: U1.W10 (PE7); also elsewhere on the board
GPS_TXD: U1.Y12 (PE8); also elsewhere on the board
HSE_IN: U1.T1 (PH0); also elsewhere on the board
LCD_B0: U1.B8 (PJ12); also elsewhere on the board
LCD_B1: U1.A7 (PJ13); also elsewhere on the board
LCD_B2: U1.B7 (PJ14); also elsewhere on the board
LCD_B3: U1.C7 (PJ15); also elsewhere on the board
LCD_B4: U1.J6 (PI4); also elsewhere on the board
LCD_B5: U1.F2 (PI5); also elsewhere on the board
LCD_B6: U1.G5 (PI6); also elsewhere on the board
LCD_B7: U1.F1 (PI7); also elsewhere on the board
LCD_CLK: U1.D2 (PI14); also elsewhere on the board
LCD_DE: U1.B5 (PK7); also elsewhere on the board
LCD_G0: U1.L4 (PJ7); also elsewhere on the board
LCD_G1: U1.H6 (PJ8); also elsewhere on the board
LCD_G2: U1.L2 (PJ9); also elsewhere on the board
LCD_G3: U1.J3 (PJ10); also elsewhere on the board
LCD_G4: U1.K6 (PJ11); also elsewhere on the board
LCD_G5: U1.D8 (PK0); also elsewhere on the board
LCD_G6: U1.E2 (PI1); also elsewhere on the board
LCD_G7: U1.E1 (PI2); also elsewhere on the board
LCD_HSYNC: U1.W1 (PI10); also elsewhere on the board
LCD_R0: U1.F3 (PI15); also elsewhere on the board
LCD_R1: U1.J2 (PJ0); also elsewhere on the board
LCD_R2: U1.L6 (PJ1); also elsewhere on the board
LCD_R3: U1.K4 (PJ2); also elsewhere on the board
LCD_R4: U1.J1 (PJ3); also elsewhere on the board
LCD_R5: U1.K2 (PJ4); also elsewhere on the board
LCD_R6: U1.K1 (PJ5); also elsewhere on the board
LCD_R7: U1.L5 (PJ6); also elsewhere on the board
LCD_VSYNC: U1.H1 (PI13); also elsewhere on the board
LED_G1: U1.C10 (PD0); also elsewhere on the board
LED_G2: U1.B10 (PD1); also elsewhere on the board
LED_R1: U1.C9 (PD4); also elsewhere on the board
LED_R2: U1.A9 (PD5); also elsewhere on the board
MOTOR_DIR: U1.D9 (PF5); also elsewhere on the board
MOTOR_PULSE: U1.Y8 (PG8); also elsewhere on the board
M_DIR_OC: U406.14 (Y4); also elsewhere on the board
unnamed: J401.5 (CLK), R410.2
unnamed: J402.3 (D+), U402.1 (I/O1)
unnamed: J402.2 (D-), U402.3 (I/O2)
unnamed: C409.1, C410.1, F401.2, J402.1 (VBUS), U402.5 (VBUS)
unnamed: J403.A5 (CC1), R411.1
unnamed: J403.B5 (CC2), R412.1
unnamed: J403.A6 (D+), J403.B6 (D+), U403.1 (I/O1)
unnamed: J403.A7 (D-), J403.B7 (D-), U403.3 (I/O2)
unnamed: J404.A5 (CC1), R415.1
unnamed: J404.B5 (CC2), R416.1
unnamed: J404.A6 (D+), J404.B6 (D+), U404.1 (I/O1)
unnamed: J404.A7 (D-), J404.B7 (D-), U404.3 (I/O2)
unnamed: C401.1, C402.1, U401.C2 (VDDI)
unnamed: C412.1, J403.A4 (VBUS), J403.A9 (VBUS), J403.B4 (VBUS), J403.B9 (VBUS), R413.1, U403.5 (VBUS)
unnamed: C413.1, J404.A4 (VBUS), J404.A9 (VBUS), J404.B4 (VBUS), J404.B9 (VBUS), U404.5 (VBUS)
unnamed: U404.6 (I/O1), U405.1 (UD+)
unnamed: U404.4 (I/O2), U405.2 (UD-)
OC1: U406.18 (Y0); also elsewhere on the board
OC2: U406.17 (Y1); also elsewhere on the board
OC3: U406.16 (Y2); also elsewhere on the board
OC4: U406.15 (Y3); also elsewhere on the board
OTG_ID: R414.2, U1.Y17 (PA10)
OTG_VBUS: R413.2; also elsewhere on the board
PHY_RST: U1.D7 (PE1); also elsewhere on the board
PMIC_INT: U1.AA3 (PA0); also elsewhere on the board
PMIC_SCL: U1.G1 (PZ4); also elsewhere on the board
PMIC_SDA: U1.H4 (PZ5); also elsewhere on the board
PMIC_WAKEUP: U1.N2 (PC13); also elsewhere on the board
SD_CD: J401.9 (DET), R409.2, U1.F15 (PE4)
SD_CK: R410.1, U1.E12 (PC12)
SD_CMD: J401.3 (CMD), R408.2, U1.D12 (PD2)
SD_D0: J401.7 (DAT0), R404.2, U1.E14 (PC8)
SD_D1: J401.8 (DAT1), R405.2, U1.D14 (PC9)
SD_D2: J401.1 (DAT2), R406.2, U1.F14 (PC10)
SD_D3: J401.2 (DAT3/CD), R407.2, U1.D15 (PC11)
TP_INT: U1.E9 (PE6); also elsewhere on the board
TP_RST: U1.W11 (PE9); also elsewhere on the board
TP_SCL: U1.AB8 (PB8); also elsewhere on the board
TP_SDA: U1.F12 (PB9); also elsewhere on the board
USB1_DM: U402.4 (I/O2); also elsewhere on the board
USB1_DP: U402.6 (I/O1); also elsewhere on the board
USB2_DM: U403.4 (I/O2); also elsewhere on the board
USB2_DP: U403.6 (I/O1); also elsewhere on the board
VBUS_SW: C411.1, F401.1; also elsewhere on the board
VDD: C405.1, C406.1, R401.1, R402.1, R403.1, R409.1, R414.1, U401.C6 (VCCQ), U401.M4 (VCCQ), U401.N4 (VCCQ), U401.P3 (VCCQ), U401.P5 (VCCQ); also elsewhere on the board
VDD_SD: C407.1, C408.1, J401.4 (VDD), R404.1, R405.1, R406.1, R407.1, R408.1; also elsewhere on the board

Notes on the sheet:
上段: eMMC (EV1 MB1263 p.9、VCC=+3.3V、VCCQ=VDD、DAT0・CMD・RSTn を10kでプルアップ) と microSD (VDD_SD、47kプルアップ、SD_CD) 下段: USB-1 (USB-A ホスト、VBUS_SW → PTC 200mA)、USB-2 (USB-C、OTGのデバイス、OTG_IDは10kでプルアップ)、 デバッグ (USB-C → CH340N → UART4、+3.3Vで動作)。USB-C の CC1/CC2 は 5.1k でプルダウン、D+/D- に USBLC6-2SC6 要確認: microSD TF-01A・USB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
SoC GPIO: ピン割当は ACROSS_V3_CubeMX入力表.csv から自動生成 (未使用ピンは未接続マーク) ・GPS_1PPS は PH12 (TIM5_CH3、M4) と PG3 (A7) の両方につなぐ ・HSE_IN = PH0-OSC_IN (デジタルバイパス)。PH1-OSC_OUT は未使用
